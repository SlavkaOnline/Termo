# Keil uVision project Termo2v1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Termo2v1
  c flags: Optim=1
  c include: .\modbus\include;.\modbus\functions;.\modbus\port;.\modbus\rtu;.\flash
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group src
    ./: LPC2300.s main.c
  group MyLibrary
    ./: led.c led7.c SSP.c timer.c irc.c softTimer.c data.c default.h i2c.c includes.h
  group ModBus RTU
    ./modbus/: mb.c
    ./modbus/rtu/: mbcrc.c mbrtu.c
    ./modbus/port/: port.c portevent.c portserial.c porttimer.c
    ./modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Flash
    ./: flashWork.c
    ./flash/: File_Config.c FS_SPI_FlashPrg.c Retarget.c SPI_LPC23xx.c FS_ARM_L.lib
